# Keil uVision project Client.uvproj, settings and files
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Client +hex
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Files
    ./: Client.c Load_pic.c
  group Configuration Files
    ./IP/: Net_Config.c Net_Debug.c
  group Library
    ./System/: startup_LPC17xx.s system_LPC17xx.c
    ./IP/: EMAC_LPC17xx.c TCP_CM3.lib TCPD_CM3.lib
  group GLCD
    ./GLCD/: GLCD_LPC1700.c
target MCB1700 Debug (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Client
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
